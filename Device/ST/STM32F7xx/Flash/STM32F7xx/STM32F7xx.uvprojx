# Keil uVision project STM32F7xx.uvprojx, settings and files
target STM32F7x_1024 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7x_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM,STM32F7x_1024
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32F7x_TCM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7x_TCM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_TCM
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F7x_512 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7x_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM,STM32F7x_512
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F7x_2048 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7x_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM,STM32F7x_2048
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F7x_2048dual (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7x_2048dual
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM,STM32F7x_2048dual
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F7xTCM_2048dual (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7xTCM_2048dual
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: STM32F7xTCM_2048dual
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F7xTCM_2048 (ARM-ADS)
  device: STM32H7_CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x200000) IRAM(0x10000000,0x58000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F7xTCM_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: STM32F7xTCM_2048
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x10000000 size 0x58000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F7x_1024dual (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: STM32F7x_1024dual
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM,STM32F7x_1024
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
